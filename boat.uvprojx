# Keil uVision project boat.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: boat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F030x6
  c include: ./;.\Core\Drivers\CMSIS\Core\Include;.\Core\Drivers\CMSIS\Device\ST\STM32F0xx\Include;.\Core\Drivers\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm;.\Core\Drivers\STM32F0xx_HAL_Driver\Inc;.\Core\Drivers\STM32F0xx_HAL_Driver\Src
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: Source.cpp
  group New Group
    ./Core/Drivers/CMSIS/Device/ST/STM32F0xx/Include/: system_stm32f0xx.h stm32f0xx.h stm32f030x6.h
    ./Core/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./Core/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x6.s
